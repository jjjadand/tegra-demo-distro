SUMMARY = "Seeed Jetson runtime image aligned with the OE4T demo image stack"

require seeed-image-jetson-runtime.inc
